options:
  parameters:
    generate_options: qt_gui
    id: Flag1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: base
  id: variable
  parameters:
    value: os.path.expanduser("~/projects/amr-thesis")
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: '200000'
    value: '2000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '50'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '-20000 + 700'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/grc-gnu/projects/amr-thesis/data/grcon26/signal-id/Signal_ID_1/sigid.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: 1/100
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '50'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/grc-gnu/Documents/NewFlag.wav
    format: FORMAT_WAV
    samp_rate: samp_rate//decim
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      MORSE = {
          '.-': 'A', '-...': 'B', '-.-.': 'C', '-..': 'D', '.': 'E',
          '..-.': 'F', '--.': 'G', '....': 'H', '..': 'I', '.---': 'J',
          '-.-': 'K', '.-..': 'L', '--': 'M', '-.': 'N', '---': 'O',
          '.--.': 'P', '--.-': 'Q', '.-.': 'R', '...': 'S', '-': 'T',
          '..-': 'U', '...-': 'V', '.--': 'W', '-..-': 'X', '-.--': 'Y',
          '--..': 'Z', '-----': '0', '.----': '1', '..---': '2',
          '...--': '3', '....-': '4', '.....': '5', '-....': '6',
          '--...': '7', '---..': '8', '----.': '9',
          '-.--.': '(', '-.--.-': ')', '..--.-': '_', '-...-': '=',
      }

      class blk(gr.sync_block):
          def __init__(self, samp_rate=10000, threshold=0.006, unit_ms=65):
              gr.sync_block.__init__(
                  self,
                  name='Morse decoder',
                  in_sig=[np.float32],
                  out_sig=None
              )
              self.samp_rate = samp_rate
              self.threshold = threshold
              self.unit_ms = unit_ms
              self.state = False
              self.count = 0
              self.letter = ''   # dots and dashes collected so far

          def finish_letter(self):
              if self.letter:
                  print(MORSE.get(self.letter, '?'), end='', flush=True)
                  self.letter = ''

          def work(self, input_items, output_items):
              for x in input_items[0]:
                  on = x > self.threshold
                  if on == self.state:
                      self.count += 1
                      continue

                  # State flipped: measure the stretch that just ended, in units
                  units = self.count / self.samp_rate * 1000 / self.unit_ms

                  if self.state:                       # an ON just ended
                      self.letter += '.' if units < 2 else '-'
                  else:                                # an OFF just ended
                      if units >= 5:                   # word gap
                          self.finish_letter()
                          print(' ', end='', flush=True)
                      elif units >= 2:                 # letter gap
                          self.finish_letter()
                      # under 2 units: gap inside a letter, do nothing

                  self.state = on
                  self.count = 1
              return len(input_items[0])
    samp_rate: samp_rate//decim
    threshold: '0.006'
    unit_ms: '65'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bw/2, bw/10)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10000'
    srate: samp_rate/decim
    type: float
    ymax: '0.025'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
