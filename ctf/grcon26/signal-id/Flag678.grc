options:
  parameters:
    generate_options: qt_gui
    id: SigID1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: base
  id: variable
  parameters:
    value: os.path.expanduser("~/projects/amr-thesis")
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: '200000'
    value: '180000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '-140000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: add_left
  id: blocks_add_xx
  parameters:
    comment: Left
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/grc-gnu/projects/amr-thesis/data/grcon26/signal-id/Signal_ID_1/sigid.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: base + "/ctf/grcon26/signal-id/fm_m140k_left.wav"
    format: FORMAT_WAV
    samp_rate: '25000'
  states: {state: disabled}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: base + "/ctf/grcon26/signal-id/fm_m140k_right.wav"
    format: FORMAT_WAV
    samp_rate: '25000'
  states: {state: disabled}
- name: const_rx_rds
  id: digital_constellation_receiver_cb
  parameters:
    comment: 'Step 6: fix rotation, sample -> 0/1'
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi/100
  states: {state: disabled}
- name: diff_dec_rds
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    comment: 'Step 7: undo differential coding'
    modulus: '2'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*8 + [-1]*8'
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bw/2, bw/10)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '57000'
    decim: '1'
    samp_rate: '250000'
    taps: firdes.low_pass(1, samp_rate/decim, 2400, 600)
    type: fcf
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: lpf_mono
  id: low_pass_filter
  parameters:
    comment: Mono (L+R)
    cutoff_freq: '15000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate/decim
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: lpf_stereo
  id: low_pass_filter
  parameters:
    comment: Stereo (L-R)
    cutoff_freq: '15000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate/decim
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: mix_38k
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: qtgui_const_sink_rds
  id: qtgui_const_sink_x
  parameters:
    comment: Each dot = one bit
    name: '"RDS bits"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '320'
    srate: '19000'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM decoder
    gain: '1'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '19'
    type: ccc
  states: {state: disabled}
- name: rds_text
  id: epy_block
  parameters:
    _source_code: |
      """
      RDS text decoder (replaces gr-rds RDS Decoder + RDS Parser).

      Input: one bit per byte (0 or 1), straight from the Differential Decoder.
      Prints the station name (PS) and RadioText (RT) to the console whenever they change.

      How it works:
        RDS sends data in "groups" of 4 blocks (A, B, C, D), 26 bits each = 104 bits.
        Each block = 16 data bits + 10 check bits. The check bits are mixed with a
        known "offset word" that is different for A, B, C and D. So by checking the
        last 104 bits, we can tell when a full group has just arrived.
        Block B says what kind of group it is:
          type 0A -> 2 characters of the station name (PS, 8 chars total)
          type 2A -> 4 characters of RadioText (RT, up to 64 chars)
      """
      import numpy as np
      from gnuradio import gr

      POLY = 0x5B9                              # RDS check polynomial (x^10+x^8+x^7+x^5+x^4+x^3+1)
      OFFSETS = {0x0FC: 'A', 0x198: 'B', 0x168: 'C', 0x350: 'C', 0x1B4: 'D'}


      def syndrome(word26):
          """Remainder of a 26-bit block divided by the RDS polynomial."""
          r = word26
          for i in range(25, 9, -1):
              if r >> i & 1:
                  r ^= POLY << (i - 10)
          return r


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name='RDS text decoder', in_sig=[np.uint8], out_sig=None)
              self.window = 0                   # last 104 bits, newest bit at the right
              self.nbits = 0
              self.ps = [' '] * 8
              self.rt = [' '] * 64
              self.last_print = ''

          def work(self, input_items, output_items):
              for b in input_items[0]:
                  self.window = ((self.window << 1) | int(b & 1)) & ((1 << 104) - 1)
                  self.nbits += 1
                  if self.nbits >= 104:
                      self.check_group()
              return len(input_items[0])

          def check_group(self):
              blocks = [(self.window >> (26 * (3 - k))) & 0x3FFFFFF for k in range(4)]
              names = [OFFSETS.get(syndrome(w)) for w in blocks]
              if names != ['A', 'B', 'C', 'D']:
                  return
              a, b, c, d = [w >> 10 for w in blocks]   # keep the 16 data bits
              group_type, version = b >> 12, (b >> 11) & 1
              if group_type == 0:                       # station name
                  i = b & 3
                  self.ps[2 * i:2 * i + 2] = [chr(d >> 8), chr(d & 0xFF)]
              elif group_type == 2 and version == 0:    # RadioText
                  i = b & 15
                  self.rt[4 * i:4 * i + 4] = [chr(c >> 8), chr(c & 0xFF), chr(d >> 8), chr(d & 0xFF)]
              text = 'PS: [%s]   RT: [%s]' % (''.join(self.ps), ''.join(self.rt).split('\r')[0].rstrip())
              if text != self.last_print:
                  print(text, flush=True)
                  self.last_print = text
    comment: 'Step 8: bits -> text (prints to console)'
  states: {state: disabled}
- name: sub_right
  id: blocks_sub_xx
  parameters:
    comment: Right
    type: float
  states: {state: disabled}
- name: symbol_sync_rds
  id: digital_symbol_sync_xx
  parameters:
    comment: 'Step 5: one sample per bit'
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {state: disabled}
- name: tone_38k
  id: analog_sig_source_x
  parameters:
    amp: '2'
    comment: 38 kHz tone. If voices still mixed, try Sine
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/decim
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}

connections:
- [add_left, '0', blocks_wavfile_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [const_rx_rds, '0', diff_dec_rds, '0']
- [diff_dec_rds, '0', rds_text, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', symbol_sync_rds, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', quad_demod, '0']
- [freq_xlating_fir_filter_xxx_1, '0', rational_resampler_xxx_0, '0']
- [lpf_mono, '0', add_left, '0']
- [lpf_mono, '0', sub_right, '0']
- [lpf_stereo, '0', add_left, '1']
- [lpf_stereo, '0', sub_right, '1']
- [mix_38k, '0', lpf_stereo, '0']
- [quad_demod, '0', freq_xlating_fir_filter_xxx_1, '0']
- [quad_demod, '0', lpf_mono, '0']
- [quad_demod, '0', mix_38k, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [sub_right, '0', blocks_wavfile_sink_1, '0']
- [symbol_sync_rds, '0', const_rx_rds, '0']
- [symbol_sync_rds, '0', qtgui_const_sink_rds, '0']
- [tone_38k, '0', mix_38k, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
