options:
  parameters:
    generate_options: qt_gui
    id: Flag13
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: base
  id: variable
  parameters:
    value: os.path.expanduser("~/projects/amr-thesis")
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: '200000'
    value: '8000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: os.path.join(base, "data/grcon26/signal-id/Signal_ID_1/sigid.sigmf-data")
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/andrew/Downloads/newflag.wav
    format: FORMAT_WAV
    samp_rate: samp_rate//decim
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.03'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      PREAMBLE = 0xAB   # sent 16 times before every alert header: 10101011


      class Reader:
          """Reads bytes (8 bits, smallest bit first) once it has found the preamble."""
          def __init__(self, invert):
              self.invert = invert
              self.reg = 0          # last 16 bits
              self.locked = False
              self.byte = 0
              self.nbits = 0
              self.text = ''

          def push(self, bit):
              bit ^= self.invert
              if not self.locked:
                  # Step 2: look for two preamble bytes in a row (bits arrive smallest-first)
                  self.reg = ((self.reg >> 1) | (bit << 15)) & 0xFFFF
                  if self.reg == (PREAMBLE << 8) | PREAMBLE:
                      self.locked, self.byte, self.nbits, self.text = True, 0, 0, ''
                  return None
              # Step 3: build bytes, smallest bit first
              self.byte |= bit << self.nbits
              self.nbits += 1
              if self.nbits < 8:
                  return None
              b, self.byte, self.nbits = self.byte, 0, 0
              if b == PREAMBLE and not self.text:
                  return None                      # still in the preamble
              if 32 <= b < 127:
                  self.text += chr(b)
                  return None
              # a non-text byte = end of this header
              self.locked, self.reg = False, 0
              return self.text if len(self.text) >= 4 else None


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Weather alert (SAME) decoder',
                  in_sig=[np.uint8],   # one 0/1 per bit (520.83 bits/s), from the Binary Slicer
                  out_sig=None
              )
              # we don't know which tone the slicer calls 1, so read both ways
              self.readers = [Reader(0), Reader(1)]
              self.counts = {}      # how many times each header has been read

          def work(self, input_items, output_items):
              for b in input_items[0]:
                  for r in self.readers:
                      msg = r.push(int(b))
                      if msg:
                          # Step 4: headers repeat, so only trust one we've read twice identically
                          self.counts[msg] = self.counts.get(msg, 0) + 1
                          if self.counts[msg] == 2:
                              print(f"Alert: {msg}", flush=True)
              return len(input_items[0])
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bw/2, bw/10)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1823'
    decim: '1'
    samp_rate: samp_rate/decim
    taps: firdes.low_pass(1, samp_rate/decim, 800, 200)
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '10000'
    srate: samp_rate/decim
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//decim
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '5'
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_0, '0', dc_blocker_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [dc_blocker_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
