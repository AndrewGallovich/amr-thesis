options:
  parameters:
    generate_options: qt_gui
    id: Flag10
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: base
  id: variable
  parameters:
    value: os.path.expanduser("~/projects/amr-thesis")
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: '200000'
    value: '15000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '25'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '110000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/grc-gnu/projects/amr-thesis/data/grcon26/signal-id/Signal_ID_1/sigid.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      SYNC = 0x7CD215D8   # "a batch starts here" marker
      IDLE = 0x7A89C197   # "nothing to send" filler
      MASK = 0xFFFFFFFF
      NUMERIC = '0123456789.U -)('   # pager digits (4 bits each)


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Pager (POCSAG) decoder',
                  in_sig=[np.uint8],   # one 0/1 per bit, from the Binary Slicer
                  out_sig=None         # prints to the console
              )
              self.reg = 0             # last 32 bits, used to spot the marker
              self.synced = False      # inside a batch?
              self.invert = False      # 0s and 1s flipped?
              self.word = 0            # current 32-bit word being collected
              self.nbits = 0
              self.count = 0           # words read in this batch (16 per batch)
              self.addr = None         # who the current message is for
              self.func = 0
              self.msg_bits = []       # message bits collected so far

          def work(self, input_items, output_items):
              for b in input_items[0]:
                  b = int(b)
                  if not self.synced:
                      # Step 1: look for the marker (or its flipped version)
                      self.reg = ((self.reg << 1) | b) & MASK
                      if self.reg in (SYNC, SYNC ^ MASK):
                          self.invert = self.reg != SYNC
                          self.start_batch()
                      continue

                  # Step 2: collect 32-bit words
                  self.word = (self.word << 1) | (b ^ self.invert)
                  self.nbits += 1
                  if self.nbits < 32:
                      continue
                  word, self.word, self.nbits = self.word, 0, 0

                  if self.count == 16:             # a batch is 16 words, then a new marker
                      if word == SYNC:
                          self.count = 0
                      else:                        # transmission ended
                          self.flush()
                          self.synced = False
                          self.reg = 0
                      continue

                  self.handle(word, self.count // 2)
                  self.count += 1
              return len(input_items[0])

          def start_batch(self):
              self.synced = True
              self.word = 0
              self.nbits = 0
              self.count = 0

          # Step 3: each word is either an address, message data, or filler
          def handle(self, word, frame):
              if word == IDLE:
                  self.flush()
              elif word >> 31 == 0:                # first bit 0 = address
                  self.flush()
                  self.addr = (((word >> 13) & 0x3FFFF) << 3) | frame
                  self.func = (word >> 11) & 0x3
                  self.msg_bits = []
              else:                                # first bit 1 = 20 bits of message
                  data = (word >> 11) & 0xFFFFF
                  self.msg_bits += [(data >> (19 - i)) & 1 for i in range(20)]

          # Step 4: message bits -> text (letters are 7 bits, digits 4 bits)
          def flush(self):
              if self.addr is None:
                  return
              bits = self.msg_bits
              letters = ''.join(
                  chr(sum(bits[i + k] << k for k in range(7)))
                  for i in range(0, len(bits) - 6, 7))
              letters = ''.join(c for c in letters if 32 <= ord(c) < 127)
              digits = ''.join(
                  NUMERIC[sum(bits[i + k] << k for k in range(4))]
                  for i in range(0, len(bits) - 3, 4))
              print(f"Pager {self.addr} (type {self.func}):", flush=True)
              print(f"   as letters: {letters}", flush=True)
              print(f"   as digits:  {digits.strip()}", flush=True)
              self.addr = None
              self.msg_bits = []
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bw/2, bw/10)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '10000'
    srate: samp_rate/decim
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '100'
    srate: '1200'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '3'
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
