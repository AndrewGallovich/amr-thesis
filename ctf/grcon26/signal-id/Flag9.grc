options:
  parameters:
    generate_options: qt_gui
    id: Flag9
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: base
  id: variable
  parameters:
    value: os.path.expanduser("~/projects/amr-thesis")
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: '200000'
    value: '8000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '50'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '80000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/grc-gnu/projects/amr-thesis/data/grcon26/signal-id/Signal_ID_1/sigid.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/grc-gnu/Downloads/NewFlag.wav
    format: FORMAT_WAV
    samp_rate: samp_rate//decim
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      def crc_x25(data):
          """Packet radio's error check (CRC-16). Same idea as the RDS check bits."""
          crc = 0xFFFF
          for b in data:
              crc ^= b
              for _ in range(8):
                  crc = (crc >> 1) ^ 0x8408 if crc & 1 else crc >> 1
          return crc ^ 0xFFFF


      def callsign(addr7):
          """Each address is 6 letters shifted left by 1 bit, plus 1 byte for the number."""
          name = ''.join(chr(b >> 1) for b in addr7[:6]).strip()
          ssid = (addr7[6] >> 1) & 0x0F
          return f"{name}-{ssid}" if ssid else name


      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Packet radio decoder',
                  in_sig=[np.uint8],   # one 0/1 per bit, from the Binary Slicer
                  out_sig=None         # prints to the console
              )
              self.prev_level = 0      # beep level of the previous bit
              self.ones = 0            # how many 1 bits in a row
              self.in_frame = False    # between two flags?
              self.bits = []           # bits of the current message

          # Step 1: "did the beep change?"  changed = 0, stayed = 1
          def work(self, input_items, output_items):
              for level in input_items[0]:
                  bit = 1 if level == self.prev_level else 0
                  self.prev_level = level
                  self.push_bit(bit)
              return len(input_items[0])

          # Step 2: find the start/end markers and remove filler bits
          def push_bit(self, bit):
              if bit == 1:
                  self.ones += 1
                  if self.ones > 6:                    # 7+ ones in a row: garbage, reset
                      self.in_frame = False
                      self.bits = []
                  elif self.in_frame:
                      self.bits.append(1)
                  return

              if self.ones == 6:                       # 01111110 = start/end marker ("flag")
                  if self.in_frame:
                      self.bits = self.bits[:-6]       # drop the marker's own 1s
                      self.end_frame()
                  self.in_frame = True
                  self.bits = []
              elif self.ones == 5:                     # filler 0 after five 1s: skip it
                  pass
              elif self.in_frame:
                  self.bits.append(0)
              self.ones = 0

          # Step 3: bits -> bytes, check for errors, print the message
          def end_frame(self):
              n = len(self.bits) // 8
              if n < 18:                               # too short to be a real message
                  return
              data = bytes(sum(self.bits[i*8 + k] << k for k in range(8)) for i in range(n))
              body, fcs = data[:-2], data[-2] | (data[-1] << 8)
              if crc_x25(body) != fcs:                 # failed the error check
                  return

              dest = callsign(body[0:7])
              src = callsign(body[7:14])
              i = 14
              while not body[i - 1] & 1:               # skip any relay stations
                  i += 7
              info = body[i + 2:]                      # skip 2 control bytes
              text = info.decode('ascii', errors='replace')
              print(f"{src} > {dest}: {text}", flush=True)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bw/2, bw/10)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1700'
    decim: '1'
    samp_rate: samp_rate/decim
    taps: firdes.low_pass(1, samp_rate/decim, 1200, 300)
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '200'
    srate: samp_rate/decim
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '10000'
    srate: samp_rate/decim
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '100'
    srate: '1200'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//decim
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '6'
    type: fff
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_1, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_1, '0', rational_resampler_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_quadrature_demod_cf_1, '0']
- [rational_resampler_xxx_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
