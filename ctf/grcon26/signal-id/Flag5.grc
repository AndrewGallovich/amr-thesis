options:
  parameters:
    generate_options: qt_gui
    id: Flag5
    output_language: python
    title: Flag 5 - touch tones after the Sky King voice
  states: {}

blocks:
- name: base
  id: variable
  parameters:
    value: os.path.expanduser("~/projects/amr-thesis")
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: '200000'
    value: '12000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '50000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: os.path.join(base, "data/grcon26/signal-id/Signal_ID_1/sigid.sigmf-data")
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bw/2, bw/10)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '3500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/decim
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: os.path.expanduser("~/Downloads/flag5_audio.wav")
    format: FORMAT_WAV
    samp_rate: samp_rate//decim
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"FM audio"'
    size: '4000'
    srate: samp_rate/decim
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      LOW = [697, 770, 852, 941]           # row tones
      HIGH = [1209, 1336, 1477, 1633]      # column tones
      KEYS = [['1', '2', '3', 'A'],
              ['4', '5', '6', 'B'],
              ['7', '8', '9', 'C'],
              ['*', '0', '#', 'D']]


      class blk(gr.sync_block):
          def __init__(self, sample_rate=25000):
              gr.sync_block.__init__(
                  self,
                  name='Touch-tone (DTMF) decoder',
                  in_sig=[np.float32],   # FM audio
                  out_sig=None
              )
              self.fs = int(sample_rate)
              self.win = int(0.025 * self.fs)   # look at 25 ms at a time
              self.hop = int(0.010 * self.fs)   # ...every 10 ms
              n = np.arange(self.win)
              hann = np.hanning(self.win)
              # one "detector" per tone: how much of that exact frequency is present
              self.probes = {f: hann * np.exp(-2j * np.pi * f * n / self.fs) for f in LOW + HIGH}
              self.buf = np.zeros(0, dtype=np.float32)
              self.current = None      # key seen in the last window
              self.count = 0           # how many windows in a row
              self.emitted = False
              self.quiet = 0           # windows since the last key
              self.digits = ''

          def detect(self, s):
              s = s - s.mean()
              total = np.sum(s * s) + 1e-12
              p = {f: abs(np.dot(s, self.probes[f])) ** 2 for f in LOW + HIGH}
              lo = sorted(LOW, key=lambda f: p[f], reverse=True)
              hi = sorted(HIGH, key=lambda f: p[f], reverse=True)
              # a real key = one clearly strongest low tone AND one clearly strongest high tone
              if p[lo[0]] < 3 * p[lo[1]] or p[hi[0]] < 3 * p[hi[1]]:
                  return None
              # ...and those two tones are a big part of the sound (not just noise)
              energy = (p[lo[0]] + p[hi[0]]) * 8 / (self.win * self.win)
              if energy < 0.2 * total / self.win:
                  return None
              return KEYS[LOW.index(lo[0])][HIGH.index(hi[0])]

          def work(self, input_items, output_items):
              self.buf = np.concatenate([self.buf, input_items[0]])
              while len(self.buf) >= self.win:
                  key = self.detect(self.buf[:self.win])
                  self.buf = self.buf[self.hop:]
                  # Step 1: a key counts once it has been heard 4 windows in a row (~40 ms)
                  if key is not None and key == self.current:
                      self.count += 1
                  else:
                      self.current, self.count, self.emitted = key, 1, False
                  if key is not None:
                      self.quiet = 0
                      if self.count >= 4 and not self.emitted:
                          self.digits += key
                          self.emitted = True
                  else:
                      # Step 2: after ~0.5 s with no key, print the whole number
                      self.quiet += 1
                      if self.quiet == 50 and self.digits:
                          print(f"DTMF: {self.digits}", flush=True)
                          self.digits = ''
              return len(input_items[0])
    sample_rate: samp_rate//decim
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate//decim
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
