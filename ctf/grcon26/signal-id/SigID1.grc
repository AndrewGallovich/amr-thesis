options:
  parameters:
    generate_options: qt_gui
    id: SigID1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: base
  id: variable
  parameters:
    value: os.path.expanduser("~/projects/amr-thesis")
  states: {}
- name: bw
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: '200000'
    value: '180000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '2'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    start: '-250000'
    step: '100'
    stop: '250000'
    value: '-140000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: add_left
  id: blocks_add_xx
  parameters:
    comment: Left
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/grc-gnu/projects/amr-thesis/data/grcon26/signal-id/Signal_ID_1/sigid.sigmf-data
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: base + "/ctf/grcon26/signal-id/fm_m140k_left.wav"
    format: FORMAT_WAV
    samp_rate: '25000'
  states: {state: disabled}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: base + "/ctf/grcon26/signal-id/fm_m140k_right.wav"
    format: FORMAT_WAV
    samp_rate: '25000'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*8 + [-1]*8'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, bw/2, bw/10)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '57000'
    decim: '1'
    samp_rate: '250000'
    taps: firdes.low_pass(1, samp_rate/decim, 2400, 600)
    type: fcf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: lpf_mono
  id: low_pass_filter
  parameters:
    comment: Mono (L+R)
    cutoff_freq: '15000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate/decim
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: lpf_stereo
  id: low_pass_filter
  parameters:
    comment: Stereo (L-R)
    cutoff_freq: '15000'
    decim: '10'
    gain: '1'
    samp_rate: samp_rate/decim
    type: fir_filter_fff
    width: '3000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: mix_38k
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/decim
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '320'
    srate: '19000'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: quad_demod
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM decoder
    gain: '1'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '250'
    interp: '19'
    type: ccc
  states: {}
- name: sub_right
  id: blocks_sub_xx
  parameters:
    comment: Right
    type: float
  states: {state: disabled}
- name: tone_38k
  id: analog_sig_source_x
  parameters:
    amp: '2'
    comment: 38 kHz tone. If voices still mixed, try Sine
    freq: '38000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/decim
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}

connections:
- [add_left, '0', blocks_wavfile_sink_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', quad_demod, '0']
- [freq_xlating_fir_filter_xxx_1, '0', rational_resampler_xxx_0, '0']
- [lpf_mono, '0', add_left, '0']
- [lpf_mono, '0', sub_right, '0']
- [lpf_stereo, '0', add_left, '1']
- [lpf_stereo, '0', sub_right, '1']
- [mix_38k, '0', lpf_stereo, '0']
- [quad_demod, '0', freq_xlating_fir_filter_xxx_1, '0']
- [quad_demod, '0', lpf_mono, '0']
- [quad_demod, '0', mix_38k, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [sub_right, '0', blocks_wavfile_sink_1, '0']
- [tone_38k, '0', mix_38k, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
